PROGRAM MAIN
VAR
	bReadButtonValue : UINT;
END_VAR

bReadButtonValue := GlobalButtons.nSTATUS;

END_PROGRAM
