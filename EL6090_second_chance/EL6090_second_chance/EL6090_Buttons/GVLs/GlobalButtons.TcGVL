{attribute 'qualified_only'}
VAR_GLOBAL

bENTER AT %I* : BOOL;
nSTATUS AT %I* : UINT;

END_VAR
